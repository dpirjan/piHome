# Patch to add parameter to the interrupt callback

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Added-parameter-to-ISR-callback.patch \
"
